# Keil uVision project BalanceCar.uvprojx, settings and files
target BalanceCar (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801BFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: BalanceCar +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c misc: --diag_suppress=1
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/LCD;../Drivers/BSP/INA226;../Drivers/BSP/Motor;../Drivers/BSP/AngleSensor;../Drivers/BSP/EEPROM;../Drivers/BSP/ESP32;../Drivers/BSP/ICM42688P;../Control
  memory RVCT4: ROM 0x8000000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c i2c.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/BSP/Display
    ../Drivers/BSP/Display/: font.h lcd.c lcd.h st7735.c st7735.h st7735_reg.c st7735_reg.h oled.c oled.h
  group Drivers/BSP/INA226
    ../Drivers/BSP/INA226/: ina226.c ina226.h
  group Drivers/BSP/Motor
    ../Drivers/BSP/Motor/: motor.c motor.h encoder.c encoder.h
  group Drivers/BSP/AngleSensor
    ../Drivers/BSP/AngleSensor/: AngleSensor.c AngleSensor.h
  group Drivers/BSP/EEPROM
    ../Drivers/BSP/EEPROM/: eeprom.c eeprom.h
  group Drivers/BSP/ESP32
    ../Drivers/BSP/ESP32/: esp32.c esp32.h
  group Drivers/BSP/ICM42688P
    ../Drivers/BSP/ICM42688P/: icm42688p.h icm42688p.c
  group Control
    ../Control/: filter.c filter.h control.c control.h
  group Drivers/BSP/KEY
    ../Drivers/BSP/KEY/: key.c key.h
  group Drivers/BSP/LED
    ../Drivers/BSP/LED/: LED.c LED.h
software components: CMSIS:CORE 4.3.0
